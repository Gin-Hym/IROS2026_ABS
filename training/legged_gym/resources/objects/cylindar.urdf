Commit message: 11.25.22.51添加了box 以及射线渗透率的 写法 引入了全方位的射线

File: training/legged_gym/resources/objects/cylindar.urdf (robot description, URDF)
Before this commit: robot cylinder, 1 links, 0 joints
Links:
- link cylinder: geometry collision cylinder length=0.6 radius=0.4
